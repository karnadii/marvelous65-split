# Repository karnadii/marvelous65-split

File README.md:

# Marvelous65 Split
ALL THE FILES MOVED TO https://github.com/karnadii/marvelous65

A split version of my marvelous65 keyboard. powered by pro micro or any compatible footprint like nice!nano and nrfmicro. This keyboard is wireless ready, I have added JST-XH connection for battery and an on off switch for the battery connection. It have encoder and oled on both side. also I have added underglow footprint if you want to add underglow in your keyboard. 

## Layout
try it at [KLE](http://www.keyboard-layout-editor.com/##@_name=marvelous65%20split%3B&@_x:2.75%3B&=ENC&_x:0.25%3B&=~%0A%60&=!%0A1&=%2F@%0A2&=%23%0A3&=$%0A4&=%25%0A5&=%5E%0A6&_x:1%3B&=%2F&%0A7&=*%0A8&=(%0A9&=)%0A0&=%2F_%0A-&=+%0A%2F=&_a:6&w:2%3B&=Backspace&_x:0.25&a:4%3B&=ENC%3B&@_x:4&w:1.5%3B&=Tab&=Q&=W&=E&=R&=T&_x:1%3B&=Y&=U&=I&=O&=P&=%7B%0A%5B&=%7D%0A%5D&_w:1.5%3B&=%7C%0A%5C&_x:2.75&a:7&w:1.25&h:2&w2:1.5&h2:1&x2:-0.25%3B&=%3B&@_y:-0.75&x:2.75&a:6&h:2%3B&=OLED&_x:16.5&h:2%3B&=OLED%3B&@_y:-0.25&a:7&w:1.25&w2:1.75&l:true%3B&=&_x:2.75&a:4&w:1.75%3B&=Caps%20Lock&=A&=S&=D&=F&=G&_x:1%3B&=H&=J&=K&=L&=%2F:%0A%2F%3B&=%22%0A'&_a:6&w:2.25%3B&=Enter&_x:1.75&a:7%3B&=%3B&@_w:1.25%3B&=&=&_x:1.75&a:6&w:2.25%3B&=Shift&_a:4%3B&=Z&=X&=C&=V&=B&_x:1%3B&=N&=M&=%3C%0A,&=%3E%0A.&=%3F%0A%2F%2F&_a:6&w:1.75%3B&=Shift%3B&@_y:-0.75&x:19.25&a:7%3B&=%E2%86%91%3B&@_y:-0.25&x:4&a:6&w:1.25%3B&=Ctrl&_w:1.25%3B&=Win&_w:1.25%3B&=Alt&_a:7&w:2.25%3B&=&_a:6&w:1.25%3B&=Fn2&_x:1&a:7&w:2.75%3B&=&_a:6%3B&=Alt&=Fn&=Ctrl%3B&@_y:-0.75&x:18.25&a:7%3B&=%E2%86%90&=%E2%86%93&=%E2%86%92%3B&@_x:15&w:1.5%3B&=&_w:1.5%3B&=)

## Features
- Rotary Encoder
- 128x32 Oled display
- Wireless ready
- Promicro footprint 
- Optional RGB underglow (have to solder directly to mcu or desolder some resistor for pro micro. nice!nano and nrfmicro you can use unused pin)

## Firmware
For promicro you can use QMK and ZMK for wireless

## Case

## PCB

## Reference
This is my reference when designing the pcb
- https://github.com/Nicell/nice60

## KiCad design PCB/Marvelous65 Split.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18: C_Small; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D32, D33, D34, D35, D36, D37, D38, D39, D40, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D75, D76, D77, D78, D79, D80, D81: D; D_SOD-123
D30, D31, D41, D42, D43, D44, D45, D57, D58, D73, D74, D82, D83, D84: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
ISO_ENTER1: MX-NoLED; SW_MX
ISO_KEY1: MX-NoLED; MXOnly-1U-NoLED
J1, J5: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2, J6: Conn_01x04; PinSocket_1x04_P2.54mm_Vertical
J3, J7: AudioJack4; Jack_3.5mm_PJ320D_Horizontal
J4, J8: Conn_01x02; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
K_A1: MX-NoLED; MXOnly-1U-NoLED
K_ALT1: 1.5; MXOnly-1.5U-NoLED
K_ALT2: MX-NoLED; MXOnly-1U-NoLED
K_ALT3: 1.25; MXOnly-1.25U-NoLED
K_B1: MX-NoLED; MXOnly-1U-NoLED
K_BACKSLASH1: 1.5; MXOnly-1.5U-NoLED
K_BSPC1: 2; MXOnly-2U-NoLED
K_BSPC2: MX-NoLED; MXOnly-1U-NoLED
K_C1: MX-NoLED; MXOnly-1U-NoLED
K_CAPS1: 1.75; MXOnly-1.75U-NoLED
K_CAPS_STEP1: 1.25; MXOnly-1.25U-NoLED
K_COLON1: MX-NoLED; MXOnly-1U-NoLED
K_COMMA1: MX-NoLED; MXOnly-1U-NoLED
K_CTRL1: 1.5; MXOnly-1.5U-NoLED
K_CTRL2: MX-NoLED; MXOnly-1U-NoLED
K_CTRL3: 1.25; MXOnly-1.25U-NoLED
K_D1: MX-NoLED; MXOnly-1U-NoLED
K_DEL1: MX-NoLED; MXOnly-1U-NoLED
K_DOT1: MX-NoLED; MXOnly-1U-NoLED
K_DOWN1: MX-NoLED; MXOnly-1U-NoLED
K_E1: MX-NoLED; MXOnly-1U-NoLED
K_ENC1: MX-NoLED; MXOnly-1U-NoLED
K_ENTER1: 2.25; MXOnly-2.25U-NoLED
K_EQUAL1: MX-NoLED; MXOnly-1U-NoLED
K_F1: MX-NoLED; MXOnly-1U-NoLED
K_FN1: MX-NoLED; MXOnly-1U-NoLED
K_FN2: MX-NoLED; MXOnly-1.25U-NoLED
K_G1: MX-NoLED; MXOnly-1U-NoLED
K_GRAVE1: MX-NoLED; MXOnly-1U-NoLED
K_H1: MX-NoLED; MXOnly-1U-NoLED
K_I1: MX-NoLED; MXOnly-1U-NoLED
K_ISO_K1: MX-NoLED; MXOnly-1U-NoLED
K_J1: MX-NoLED; MXOnly-1U-NoLED
K_K1: MX-NoLED; MXOnly-1U-NoLED
K_L1: MX-NoLED; MXOnly-1U-NoLED
K_LEFT1: MX-NoLED; MXOnly-1U-NoLED
K_LSHIFT1: 2.25; MXOnly-2.25U-NoLED
K_L_PAR1: MX-NoLED; MXOnly-1U-NoLED
K_M1: MX-NoLED; MXOnly-1U-NoLED
K_MINUS1: MX-NoLED; MXOnly-1U-NoLED
K_N1: MX-NoLED; MXOnly-1U-NoLED
K_NUM0, K_NUM1, K_NUM2, K_NUM3, K_NUM4, K_NUM5, K_NUM6, K_NUM7, K_NUM8, K_NUM9: MX-NoLED; MXOnly-1U-NoLED
K_O1: MX-NoLED; MXOnly-1U-NoLED
K_P1: MX-NoLED; MXOnly-1U-NoLED
K_Q1: MX-NoLED; MXOnly-1U-NoLED
K_QUOTE1: MX-NoLED; MXOnly-1U-NoLED
K_R1: MX-NoLED; MXOnly-1U-NoLED
K_RIGHT1: MX-NoLED; MXOnly-1U-NoLED
K_RSHIFT1: 1.75; MXOnly-1.75U-NoLED
K_R_PAR1: MX-NoLED; MXOnly-1U-NoLED
K_S1: MX-NoLED; MXOnly-1U-NoLED
K_SHIFT_ISO1: 1.25; MXOnly-1.25U-NoLED
K_SLASH1: MX-NoLED; MXOnly-1U-NoLED
K_SPACE1: 2.75; MXOnly-2.75U-ReversedStabilizers-NoLED
K_SPACE2: 2.25; MXOnly-2.25U-ReversedStabilizers-NoLED
K_T1: MX-NoLED; MXOnly-1U-NoLED
K_TAB1: 1.5; MXOnly-1.5U-NoLED
K_U1: MX-NoLED; MXOnly-1U-NoLED
K_UP1: MX-NoLED; MXOnly-1U-NoLED
K_V1: MX-NoLED; MXOnly-1U-NoLED
K_W1: MX-NoLED; MXOnly-1U-NoLED
K_WIN1: 1.25; MXOnly-1.25U-NoLED
K_X1: MX-NoLED; MXOnly-1U-NoLED
K_Y1: MX-NoLED; MXOnly-1U-NoLED
K_Z1: MX-NoLED; MXOnly-1U-NoLED
L_ENC1: MX-NoLED; MXOnly-1U-NoLED
OL1, OL2: OLED
R1, R2, R7, R8: 5.1K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R3, R4, R5, R6, R9, R10, R11, R12: R_Small; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
SW1, SW6: SW_DPDT_x2; SW_SPDT_PCM12
SW2, SW4: SW_PUSH; SW_SPST_TL3342
SW3, SW5: Rotary_Encoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
TP1, TP2: TestPoint; TestPoint_THTPad_D2.5mm_Drill1.2mm
U1, U3: ProMicro; ProMicro_v3
U2, U4: USBLC6-2SC6; SOT-23-6

Connections:
COL0: K_H1.1 (COL), K_N1.1 (COL), K_NUM7.1 (COL), K_Y1.1 (COL), U1.18 (F6/A1)
COL1: K_J1.1 (COL), K_M1.1 (COL), K_NUM8.1 (COL), K_SPACE1.1 (COL), K_U1.1 (COL), U1.17 (F7/A0)
COL2: K_ALT1.1 (COL), K_ALT2.1 (COL), K_COMMA1.1 (COL), K_I1.1 (COL), K_K1.1 (COL), K_NUM9.1 (COL), U1.16 (B1/15)
COL3: K_DOT1.1 (COL), K_FN1.1 (COL), K_L1.1 (COL), K_NUM0.1 (COL), K_O1.1 (COL), U1.10 (7/E6)
COL4: K_COLON1.1 (COL), K_CTRL1.1 (COL), K_CTRL2.1 (COL), K_MINUS1.1 (COL), K_P1.1 (COL), K_SLASH1.1 (COL), U1.15 (B3/14)
COL5: K_EQUAL1.1 (COL), K_LEFT1.1 (COL), K_L_PAR1.1 (COL), K_QUOTE1.1 (COL), U1.11 (8/B4)
COL6: ISO_KEY1.1 (COL), K_BSPC1.1 (COL), K_BSPC2.1 (COL), K_DOWN1.1 (COL), K_ENTER1.1 (COL), K_RSHIFT1.1 (COL), K_R_PAR1.1 (COL), U1.14 (B2/16)
COL7: ISO_ENTER1.1 (COL), K_BACKSLASH1.1 (COL), K_DEL1.1 (COL), K_ENC1.1 (COL), K_RIGHT1.1 (COL), K_UP1.1 (COL), SW3.S2, U1.12 (9/B5)
D+: J2.3, U2.1 (IO1)
D-: J2.2, U2.3 (IO2)
DATA: J3.T, U1.2 (RX1/D2)
GND: C1.1, C2.2, C3.1, C4.2, C5.1, C6.1, C7.2, C8.1, C9.2, C10.1, C11.2, C12.1, C13.2, C14.1, C15.2, C16.1, C17.2, C18.1, D30.3 (VSS), D31.3 (VSS), D41.3 (VSS), D42.3 (VSS), D43.3 (VSS), D44.3 (VSS), D45.3 (VSS), D57.3 (VSS), D58.3 (VSS), D73.3 (VSS), D74.3 (VSS), D82.3 (VSS), D83.3 (VSS), D84.3 (VSS), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.4, J3.R1, J4.1, J5.A1 (GND), J5.A12 (GND), J5.B1 (GND), J5.B12 (GND), J5.S1 (SHIELD), J6.4, J7.R1, J8.1, OL1.4 (GND), OL2.4 (GND), R1.1, R2.1, R7.1, R8.1, SW2.2, SW3.C, SW4.2, SW5.C, U1.3 (GND), U1.4 (GND), U1.23 (GND), U2.2 (GND), U3.3 (GND), U3.4 (GND), U3.23 (GND), U4.2 (GND)
K_ENC_A: D38.2 (A), K_ENC1.2 (ROW), SW3.S1
K_L_ENC_A: D46.2 (A), L_ENC1.2 (ROW), SW5.S1
K_L_ENC_B: L_ENC1.1 (COL), SW5.S2, U3.1 (TX0/D3)
LED_UNDERGLOW: D30.4 (DIN), TP1.1
L_COL1: K_CAPS1.1 (COL), K_CAPS_STEP1.1 (COL), K_CTRL3.1 (COL), K_GRAVE1.1 (COL), K_LSHIFT1.1 (COL), K_SHIFT_ISO1.1 (COL), K_TAB1.1 (COL), U3.13 (B6/10)
L_COL2: K_A1.1 (COL), K_ISO_K1.1 (COL), K_NUM1.1 (COL), K_Q1.1 (COL), K_WIN1.1 (COL), U3.11 (8/B4)
L_COL3: K_ALT3.1 (COL), K_NUM2.1 (COL), K_S1.1 (COL), K_W1.1 (COL), K_Z1.1 (COL), U3.14 (B2/16)
L_COL4: K_D1.1 (COL), K_E1.1 (COL), K_NUM3.1 (COL), K_X1.1 (COL), U3.9 (6/D7)
L_COL5: K_C1.1 (COL), K_F1.1 (COL), K_NUM4.1 (COL), K_R1.1 (COL), K_SPACE2.1 (COL), U3.10 (7/E6)
L_COL6: K_FN2.1 (COL), K_G1.1 (COL), K_NUM5.1 (COL), K_T1.1 (COL), K_V1.1 (COL), U3.15 (B3/14)
L_COL7: K_B1.1 (COL), K_NUM6.1 (COL), U3.17 (F7/A0)
L_D+: J6.3, U4.1 (IO1)
L_D-: J6.2, U4.3 (IO2)
L_DATA: J7.T, U3.2 (RX1/D2)
L_LED_UNDERGLOW: D57.4 (DIN), TP2.1
L_RAW: SW6.2 (B), U3.24 (RAW)
L_RAW_BAT: J8.2, SW6.3 (C)
L_RESET: SW4.1, U3.22 (RST)
L_ROT_A: R9.2, U3.7 (4/D4)
L_ROT_B: R12.1, U3.8 (5/C6)
L_ROW0: D46.1 (K), D47.1 (K), D52.1 (K), D59.1 (K), D64.1 (K), D68.1 (K), D75.1 (K), D80.1 (K), U3.20 (F4/A3)
L_ROW1: D48.1 (K), D53.1 (K), D60.1 (K), D65.1 (K), D69.1 (K), D76.1 (K), U3.19 (F5/A2)
L_ROW2: D49.1 (K), D54.1 (K), D61.1 (K), D66.1 (K), D70.1 (K), D77.1 (K), U3.18 (F6/A1)
L_ROW3: D50.1 (K), D55.1 (K), D62.1 (K), D67.1 (K), D71.1 (K), D78.1 (K), D81.1 (K), U3.16 (B1/15)
L_ROW4: D51.1 (K), D56.1 (K), D63.1 (K), D72.1 (K), D79.1 (K), U3.12 (9/B5)
L_SCL: OL2.2 (SCL), U3.6 (3/D0/SCL)
L_SDA: OL2.1 (SDA), U3.5 (2/D1/SDA)
L_VBUS: J5.A4 (VBUS), J5.A9 (VBUS), J5.B4 (VBUS), J5.B9 (VBUS), J6.1, U4.5 (VBUS)
L_connD+: J5.A6 (D+), J5.B6 (D+), U4.6 (IO1)
L_connD-: J5.A7 (D-), J5.B7 (D-), U4.4 (IO2)
unnamed: C6.2, R3.1, R4.1, SW3.A
unnamed: C8.2, R5.1, R6.2, SW3.B
unnamed: C16.2, R9.1, R10.1, SW5.A
unnamed: C18.2, R11.1, R12.2, SW5.B
unnamed: D1.2 (A), K_NUM7.2 (ROW)
unnamed: D2.2 (A), K_Y1.2 (ROW)
unnamed: D3.2 (A), K_H1.2 (ROW)
unnamed: D4.2 (A), K_N1.2 (ROW)
unnamed: D5.2 (A), K_NUM8.2 (ROW)
unnamed: D6.2 (A), K_U1.2 (ROW)
unnamed: D7.2 (A), K_J1.2 (ROW)
unnamed: D8.2 (A), K_M1.2 (ROW)
unnamed: D9.2 (A), K_SPACE1.2 (ROW)
unnamed: D10.2 (A), K_NUM9.2 (ROW)
unnamed: D11.2 (A), K_I1.2 (ROW)
unnamed: D12.2 (A), K_K1.2 (ROW)
unnamed: D13.2 (A), K_COMMA1.2 (ROW)
unnamed: D14.2 (A), K_ALT1.2 (ROW), K_ALT2.2 (ROW)
unnamed: D15.2 (A), K_NUM0.2 (ROW)
unnamed: D16.2 (A), K_O1.2 (ROW)
unnamed: D17.2 (A), K_L1.2 (ROW)
unnamed: D18.2 (A), K_DOT1.2 (ROW)
unnamed: D19.2 (A), K_FN1.2 (ROW)
unnamed: D20.2 (A), K_MINUS1.2 (ROW)
unnamed: D21.2 (A), K_P1.2 (ROW)
unnamed: D22.2 (A), K_COLON1.2 (ROW)
unnamed: D23.2 (A), K_SLASH1.2 (ROW)
unnamed: D24.2 (A), K_CTRL1.2 (ROW), K_CTRL2.2 (ROW)
unnamed: D25.2 (A), K_EQUAL1.2 (ROW)
unnamed: D26.2 (A), K_L_PAR1.2 (ROW)
unnamed: D27.2 (A), K_QUOTE1.2 (ROW)
unnamed: D28.2 (A), K_LEFT1.2 (ROW)
unnamed: D29.2 (A), K_R_PAR1.2 (ROW)
unnamed: D30.2 (DOUT), D41.4 (DIN)
unnamed: D31.4 (DIN), D42.2 (DOUT)
unnamed: D32.2 (A), K_BSPC1.2 (ROW), K_BSPC2.2 (ROW)
unnamed: D33.2 (A), ISO_KEY1.2 (ROW), K_ENTER1.2 (ROW)
unnamed: D34.2 (A), K_RSHIFT1.2 (ROW)
unnamed: D35.2 (A), K_DOWN1.2 (ROW)
unnamed: D36.2 (A), K_DEL1.2 (ROW)
unnamed: D37.2 (A), ISO_ENTER1.2 (ROW), K_BACKSLASH1.2 (ROW)
unnamed: D39.2 (A), K_UP1.2 (ROW)
unnamed: D40.2 (A), K_RIGHT1.2 (ROW)
unnamed: D41.2 (DOUT), D43.4 (DIN)
unnamed: D42.4 (DIN), D44.2 (DOUT)
unnamed: D43.2 (DOUT), D45.4 (DIN)
unnamed: D44.4 (DIN), D45.2 (DOUT)
unnamed: D47.2 (A), K_GRAVE1.2 (ROW)
unnamed: D48.2 (A), K_TAB1.2 (ROW)
unnamed: D49.2 (A), K_CAPS1.2 (ROW), K_CAPS_STEP1.2 (ROW)
unnamed: D50.2 (A), K_LSHIFT1.2 (ROW), K_SHIFT_ISO1.2 (ROW)
unnamed: D51.2 (A), K_CTRL3.2 (ROW)
unnamed: D52.2 (A), K_NUM1.2 (ROW)
unnamed: D53.2 (A), K_Q1.2 (ROW)
unnamed: D54.2 (A), K_A1.2 (ROW)
unnamed: D55.2 (A), K_ISO_K1.2 (ROW)
unnamed: D56.2 (A), K_WIN1.2 (ROW)
unnamed: D57.2 (DOUT), D73.4 (DIN)
unnamed: D58.4 (DIN), D74.2 (DOUT)
unnamed: D59.2 (A), K_NUM2.2 (ROW)
unnamed: D60.2 (A), K_W1.2 (ROW)
unnamed: D61.2 (A), K_S1.2 (ROW)
unnamed: D62.2 (A), K_Z1.2 (ROW)
unnamed: D63.2 (A), K_ALT3.2 (ROW)
unnamed: D64.2 (A), K_NUM3.2 (ROW)
unnamed: D65.2 (A), K_E1.2 (ROW)
unnamed: D66.2 (A), K_D1.2 (ROW)
unnamed: D67.2 (A), K_X1.2 (ROW)
unnamed: D68.2 (A), K_NUM4.2 (ROW)
unnamed: D69.2 (A), K_R1.2 (ROW)
unnamed: D70.2 (A), K_F1.2 (ROW)
unnamed: D71.2 (A), K_C1.2 (ROW)
unnamed: D72.2 (A), K_SPACE2.2 (ROW)
unnamed: D73.2 (DOUT), D82.4 (DIN)
unnamed: D74.4 (DIN), D83.2 (DOUT)
unnamed: D75.2 (A), K_NUM5.2 (ROW)
unnamed: D76.2 (A), K_T1.2 (ROW)
unnamed: D77.2 (A), K_G1.2 (ROW)
unnamed: D78.2 (A), K_V1.2 (ROW)
unnamed: D79.2 (A), K_FN2.2 (ROW)
unnamed: D80.2 (A), K_NUM6.2 (ROW)
unnamed: D81.2 (A), K_B1.2 (ROW)
unnamed: D82.2 (DOUT), D84.4 (DIN)
unnamed: D83.4 (DIN), D84.2 (DOUT)
unnamed: J1.A5 (CC1), R1.2
unnamed: J1.B5 (CC2), R2.2
unnamed: J5.A5 (CC1), R7.2
unnamed: J5.B5 (CC2), R8.2
RAW: SW1.2 (B), U1.24 (RAW)
RAW_BAT: J4.2, SW1.3 (C)
RESET: SW2.1, U1.22 (RST)
ROT_A: R3.2, U1.7 (4/D4)
ROT_B: R6.1, U1.8 (5/C6)
ROW0: D1.1 (K), D5.1 (K), D10.1 (K), D15.1 (K), D20.1 (K), D25.1 (K), D32.1 (K), D36.1 (K), U1.1 (TX0/D3)
ROW1: D2.1 (K), D6.1 (K), D11.1 (K), D16.1 (K), D21.1 (K), D26.1 (K), D29.1 (K), D37.1 (K), U1.20 (F4/A3)
ROW2: D3.1 (K), D7.1 (K), D12.1 (K), D17.1 (K), D22.1 (K), D27.1 (K), D33.1 (K), D38.1 (K), U1.19 (F5/A2)
ROW3: D4.1 (K), D8.1 (K), D13.1 (K), D18.1 (K), D23.1 (K), D34.1 (K), D39.1 (K), U1.9 (6/D7)
ROW4: D9.1 (K), D14.1 (K), D19.1 (K), D24.1 (K), D28.1 (K), D35.1 (K), D40.1 (K), U1.13 (B6/10)
SCL: OL1.2 (SCL), U1.6 (3/D0/SCL)
SDA: OL1.1 (SDA), U1.5 (2/D1/SDA)
VBUS: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J2.1, U2.5 (VBUS)
VCC: C1.2, C2.1, C3.2, C4.1, C5.2, C7.1, C9.1, C10.2, C11.1, C12.2, C13.1, C14.2, C15.1, C17.1, D30.1 (VDD), D31.1 (VDD), D41.1 (VDD), D42.1 (VDD), D43.1 (VDD), D44.1 (VDD), D45.1 (VDD), D57.1 (VDD), D58.1 (VDD), D73.1 (VDD), D74.1 (VDD), D82.1 (VDD), D83.1 (VDD), D84.1 (VDD), J3.R2, J7.R2, OL1.3 (VCC), OL2.3 (VCC), R4.2, R5.2, R10.2, R11.2, U1.21 (VCC), U3.21 (VCC)
connD+: J1.A6 (D+), J1.B6 (D+), U2.6 (IO1)
connD-: J1.A7 (D-), J1.B7 (D-), U2.4 (IO2)

Board: 2 copper layers, 349.3 x 107.2 mm, 218 parts (133 on the bottom side), 146 nets.

Other parts of the board:
mouse-bite-3mm-slot, mouse-bite-3mm-slot#2, mouse-bite-3mm-slot#3, mouse-bite-3mm-slot#4, mouse-bite-3mm-slot#5: VAL**; mouse-bite-3mm-slot

## Commit log

2021-01-22 add pcb
2021-01-22 generate gerber
2021-01-22 add reference
2021-01-22 typo
2021-01-23 fix iso enter and panelization
2021-01-23 updated rendered images
2021-01-23 add schematic and gerber
2021-01-25 update breakout method
2021-01-25 update gerber
2021-02-07 add a bunch of files
2021-02-12 add sketch file
